# Keil uVision project Blinky.uvproj, settings and files
target LPC1768 Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 550
  c include: ..\MCB1700-master
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\DMA.sct
  group StartUp
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: GLCD_SPI_LPC1700.c LED.c IRQ.c Blinky.c KBD.c gameFallingObjects.c gameFallingObjects.h gameTicTacToe.c gameTicTacToe.h
  group audio
    ./audio/: adcuser.c core_cm3.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c type.h usb.h usbaudio.h usbcfg.h usbcore.h usbdesc.h usbdmain.h usbhw.h usbreg.h usbuser.h adcuser.h audio.h core_cm3.h
  group Pictures
    ./: uzi.c wayne.c ye.c nas.c michael.c liquid_swords.c Drake_128x128.c audio.c em.c
